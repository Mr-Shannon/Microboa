# Keil uVision project Project.uvprojx, settings and files
target GD32F10x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\..\Applications;..\..\Drivers;..\..\Libraries\CMSIS;..\..\Libraries\GD32F10x_StdPeriph_Driver\inc;..\..\..\..\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\spi;..\..\..\..\components\finsh;..\..\..\..\components\CMSIS\Include;..\..\..\..\components\net\lwip-1.4.1\src;..\..\..\..\components\net\lwip-1.4.1\src\include;..\..\..\..\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\..\components\net\lwip-1.4.1\src\include\netif;..\..\..\..\components\net\lwip-1.4.1\src\arch\include;..\..\..\..\components\dfs\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    ../../Applications/: main.c
  group FileSystem
    ../../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group Network
    ../../../../examples/network/: tcpserver.c tcpclient.c udpserver.c udpclient.c
  group Drivers
    ../../Drivers/: board.c gd32f10x_it.c drv_usart.c drv_spi.c drv_pn25fxx.c drv_enc28j60.c drv_pin.c
  group CMSIS
    ../../Libraries/StartUp/: startup_gd32f10x_md.s
    ../../Libraries/CMSIS/: core_cm3.c system_gd32f10x.c
  group GD32F10x_StdPeriph_Driver
    ../../Libraries/GD32F10x_StdPeriph_Driver/src/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dma.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10X_fmc.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_iwdg.c gd32f10x_mcudbg.c gd32f10x_misc.c gd32f10x_pwr.c gd32f10x_rcc.c gd32f10x_rtc.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdg.c
  group kernel
    ../../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group Cortex-M3
    ../../../../libcpu/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_pn25fxx.c enc28j60.c
    ../../../../components/drivers/misc/: pin.c
  group Finsh
    ../../../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group LwIP
    ../../../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
